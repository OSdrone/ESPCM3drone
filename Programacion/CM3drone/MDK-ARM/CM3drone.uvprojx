# Keil uVision project CM3drone.uvprojx, settings and files
target CM3drone (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CM3drone +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB, ARM_MATH_CM3
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;../Src/FuncionesRTOS;../Dispositivos
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group RTOS
    ../FuncionesRTOS/: TASK_IMU.h TASK_IMU.c TASK_COORDINADOR.h TASK_COORDINADOR.c TASK_CONTROL.h TASK_CONTROL.c TASK_COMPASS.h TASK_COMPASS.c TASK_ALTURA.h TASK_ALTURA.c TASK_AHRS.h TASK_AHRS.c
  group Dispositivos
    ../Dispositivos/: IMU_9DOF.h
  group Application/User
    ../Src/: usart.c main.c dma.c iwdg.c adc.c tim.c stm32f1xx_it.c crc.c stm32f1xx_hal_msp.c gpio.c i2c.c freertos.c AHRS.c AHRS.h Constantes.h OSmath.h ServidoresVariables.c ServidoresVariables.h OSvariables.h
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_i2c.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_crc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_adc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c list.c tasks.c event_groups.c timers.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
